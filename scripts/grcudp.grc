options:
  parameters:
    generate_options: qt_gui
    id: grcudp
    output_language: python
    title: GnuRadio UDP Receiver
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '1'
    ipv6: 'True'
    notify_missed: 'True'
    port: '2000'
    src_zeros: 'False'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: 53e6
    fftsize: '4096'
    grid: 'True'
    showports: 'True'
    tr_level: '-50'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
    update_time: '0.1'
    ymax: '0'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: int(20e-3*samp_rate)
    srate: samp_rate
    tr_delay: '2e-3'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
  states: {}

connections:
- [network_udp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [network_udp_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
